MAGIC HALF ADDER

.include TSMC_180nm.txt
.global gnd vdd

.option scale=0.09u

*********
*netlist*
*********
Vdd vdd gnd 1

M1000 sum a a_19_n40# Gnd CMOSN w=8 l=4
+  ad=144 pd=68 as=168 ps=58
M1001 carry a_22_n167# gnd Gnd CMOSN w=4 l=4
+  ad=52 pd=34 as=474 ps=296
M1002 a_89_7# a vdd vdd CMOSP w=16 l=4
+  ad=336 pd=74 as=985 ps=456
M1003 a_15_n3# a gnd Gnd CMOSN w=4 l=4
+  ad=52 pd=34 as=0 ps=0
M1004 a_22_n100# b gnd Gnd CMOSN w=4 l=4
+  ad=52 pd=34 as=0 ps=0
M1005 a_15_n3# a vdd vdd CMOSP w=8 l=4
+  ad=104 pd=42 as=0 ps=0
M1006 vdd a a_22_n167# vdd CMOSP w=16 l=4
+  ad=0 pd=0 as=384 ps=80
M1007 a_89_n40# a_22_n100# gnd Gnd CMOSN w=8 l=4
+  ad=168 pd=58 as=0 ps=0
M1008 sum a_22_n100# a_89_7# vdd CMOSP w=16 l=4
+  ad=288 pd=100 as=0 ps=0
M1009 sum b a_19_7# vdd CMOSP w=16 l=4
+  ad=0 pd=0 as=336 ps=74
M1010 a_19_n40# b gnd Gnd CMOSN w=8 l=4
+  ad=0 pd=0 as=0 ps=0
M1011 a_22_n167# b vdd vdd CMOSP w=16 l=4
+  ad=0 pd=0 as=0 ps=0
M1012 a_22_n100# b vdd vdd CMOSP w=8 l=4
+  ad=104 pd=42 as=0 ps=0
M1013 carry a_22_n167# vdd vdd CMOSP w=8 l=4
+  ad=104 pd=42 as=0 ps=0
M1014 a_22_n167# a a_22_n194# Gnd CMOSN w=8 l=4
+  ad=56 pd=30 as=192 ps=64
M1015 a_19_7# a_15_n3# vdd vdd CMOSP w=16 l=4
+  ad=0 pd=0 as=0 ps=0
M1016 a_22_n194# b gnd Gnd CMOSN w=8 l=4
+  ad=0 pd=0 as=0 ps=0
M1017 sum a_15_n3# a_89_n40# Gnd CMOSN w=8 l=4
+  ad=0 pd=0 as=0 ps=0
C0 gnd Gnd 1.81fF
C1 a Gnd 1.95fF
C2 b Gnd 1.27fF
C3 vdd Gnd 1.99fF
C4 a_15_n3# Gnd 2.17fF
C5 w_5_n173# Gnd 1.63fF
C6 vdd Gnd 1.72fF
C7 w_0_0# Gnd 1.72fF
Cout out gnd 1fF

Va a gnd pulse(0 1 0 0.1u 0.1u 10u 20u)
Vb b gnd pulse(0 1 0 0.1u 0.1u 20u 40u)

*control*

.control
tran 25us 625us
echo " ---------------------------------------------" > "half_adder_layout_delays.txt"

plot v(sum)
plot v(b)
plot v(a)
plot v(carry)

let delay_in1_LH = 0
let delay_carry_LH = 0
let delay_in1_HL = 0
let delay_carry_HL = 0
meas tran   delay_in1_LH trig v(a) val = 0.5 fall = 5 targ   v(sum) val = 0.5 rise = 5
meas tran   delay_in1_HL trig v(a) val = 0.5 fall = 2 targ   v(sum) val = 0.5 fall = 2
meas tran delay_carry_LH trig v(a) val = 0.5 rise = 7 targ v(carry) val = 0.5 rise = 7
meas tran delay_carry_HL trig v(a) val = 0.5 fall = 1 targ v(carry) val = 0.5 fall = 1
let   propDelIn1 =          (abs(delay_in1_LH) + abs(delay_in1_HL))/2
let propDelcarry = 	(abs(delay_carry_LH) + abs(delay_carry_HL))/2

echo " ---------------------------------------------" 		      > "half_adder_layout_delays.txt"
echo "|->            low to high delay_sum = " "$&delay_in1_LH|"     >> "half_adder_layout_delays.txt"
echo "|->            high to low delay_sum = " "$&delay_in1_HL|"     >> "half_adder_layout_delays.txt"
echo "|-> worst case propogation delay_sum = " " $&propDelIn1|"      >> "half_adder_layout_delays.txt"
echo " ---------------------------------------------" 		     >> "half_adder_layout_delays.txt"
echo " ---------------------------------------------" 		     >> "half_adder_layout_delays.txt"
echo "|->            low to high delay_carry = " "$&delay_carry_LH|" >> "half_adder_layout_delays.txt"
echo "|->            high to low delay_carry = " "$&delay_carry_HL|" >> "half_adder_layout_delays.txt"
echo "|-> worst case propogation delay_carry = " " $&propDelcarry|"  >> "half_adder_layout_delays.txt"
echo " ---------------------------------------------" 		     >> "half_adder_layout_delays.txt"
.endc
.end
